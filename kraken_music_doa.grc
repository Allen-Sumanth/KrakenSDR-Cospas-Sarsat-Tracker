options:
  parameters:
    generate_options: qt_gui
    id: kraken_music_doa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha_iir_0
  id: variable_qtgui_range
  parameters:
    comment: For Squelcher block
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: cpi_size
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '128'
  states: {}
- name: delay_time_s_0
  id: variable_qtgui_range
  parameters:
    comment: For Squelcher block
    start: '0'
    step: '0.5'
    stop: '5'
    value: '2'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '406.025'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: theta_deg
  id: variable_qtgui_range
  parameters:
    comment: Angle of incidence in degrees (0=North, 90=East)
    gui_hint: 0,0,1,4
    label: Angle of Incidence (degrees)
    start: '0'
    step: '1'
    stop: '360'
    value: '45'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '360'
    type: float
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.2'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.2'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.2'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.2'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0_0_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.2'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: cospas_sarsat_doa_0
  id: cospas_sarsat_doa
  parameters:
    samp_rate: samp_rate
    theta_deg: theta_deg
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, cpi_size=8192):
              """
              Custom Smart Gate: Holds the previous MUSIC spectrum when squelch is closed.
              """
              gr.sync_block.__init__(
                  self,
                  name='Squelch-Triggered Vector Gate',
                  # Hardcoded 8192 to prevent the GRC AST parser from crashing
                  in_sig=[(np.float32, 360), (np.complex64, 8192)],
                  out_sig=[(np.float32, 360)]
              )
              # Initialize the baseline floor at -140 dB
              self.held_vector = np.full(360, -140.0, dtype=np.float32)

          def work(self, input_items, output_items):
              doa_input = input_items[0]
              squelch_input = input_items[1]

              for i in range(len(doa_input)):
                  current_doa = doa_input[i]
                  current_squelch_frame = squelch_input[i]

                  # 1. Did the squelch gate open at ALL during this 437ms frame?
                  gate_open = np.max(np.abs(current_squelch_frame)) > 0.5

                  # 2. Safety Check 1: Ignore frames where MUSIC exploded into NaNs
                  if np.isnan(current_doa).any():
                      gate_open = False

                  # 3. Safety Check 2: The Flatline Trap
                  # If the signal is squelched, the 1e-6 DC offset creates a perfectly flat 0.0dB spectrum.
                  # A valid peak will have a noise floor below -3.0 dB.
                  if np.min(current_doa) > -3.0:
                      gate_open = False

                  # Output Logic
                  if gate_open:
                      # Burst detected AND valid peak! Save it to memory.
                      self.held_vector = np.copy(current_doa)
                  
                  # Safely write the held vector into the output buffer
                  output_items[0][i][:] = self.held_vector

              return len(output_items[0])
    cpi_size: cpi_size//decimation
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, mode='map_squelch', threshold=0.1):
              """
              mode: 'map_squelch' outputs zeros between bursts so the heatmap doesn't track false movement.
                    'compass_hold' persists the last burst indefinitely for visual UI dials.
              """
              gr.sync_block.__init__(
                  self,
                  name='Smart Vector Gate',
                  in_sig=[(np.float32, 360)],
                  out_sig=[(np.float32, 360)]
              )
              self.mode = mode 
              self.threshold = threshold
              self.held_vector = np.zeros(360, dtype=np.float32)

          def work(self, input_items, output_items):
              for i in range(len(input_items[0])):
                  current_vector = input_items[0][i]

                  # 1. Catch the MUSIC algorithm Divide-by-Zero (NaN) explosion
                  if np.isnan(current_vector).any():
                      is_valid = False
                  # 2. Check if the vector contains a strong, valid MUSIC peak
                  elif np.max(current_vector) > self.threshold:
                      is_valid = True
                      self.held_vector = np.copy(current_vector) # Save it to memory
                  else:
                      is_valid = False

                  # Output Logic
                  if self.mode == 'compass_hold':
                      # Continously push the last known heading (Dangerous if driving!)
                      output_items[0][i] = self.held_vector
                  else:
                      # 'map_squelch' - Push valid burst, otherwise output strict zeros
                      if is_valid:
                          output_items[0][i] = current_vector
                      else:
                          output_items[0][i] = np.zeros(360, dtype=np.float32)

              return len(output_items[0])
    mode: '''map_squelch'''
    threshold: '-0.2'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: firdes.low_pass(1.0, samp_rate, (samp_rate/decimation)/2, 1000)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: firdes.low_pass(1.0, samp_rate, (samp_rate/decimation)/2, 1000)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: firdes.low_pass(1.0, samp_rate, (samp_rate/decimation)/2, 1000)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: firdes.low_pass(1.0, samp_rate, (samp_rate/decimation)/2, 1000)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_2
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: firdes.low_pass(1.0, samp_rate, (samp_rate/decimation)/2, 1000)
    type: ccc
  states: {}
- name: krakensdr_doa_music_0
  id: krakensdr_doa_music
  parameters:
    array_dist: '0.22'
    array_type: '''UCA'''
    freq: freq
    num_elements: '5'
    vec_len: cpi_size//decimation
  states: {}
- name: krakensdr_krakensdr_source_0
  id: krakensdr_krakensdr_source
  parameters:
    ctrlPort: '5001'
    debug: 'False'
    freq: freq
    gain: '[40.2, 40.2, 40.2, 40.2, 40.2]'
    ipAddr: 127.0.0.1
    numChannels: '5'
    port: '5000'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate//decimation
    fc: '0'
    fftsize: '2048'
    name: CH_0 Decimated FFT
    type: complex
    update_time: '0.1'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: DOA Graph
    size: '360'
    srate: '1000'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '360'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: squelcher_0
  id: squelcher
  parameters:
    alpha_iir: '0.01'
    decimation: decimation
    delay_time_s: '2'
    samp_rate: samp_rate
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Noise_gate
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Noise_gate
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Noise_gate
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Noise_gate
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Noise_gate
  states: {}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: Noise_gate
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Noise_gate
  states: {}

connections:
- [blocks_multiply_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_stream_to_vector_0_0_1, '0']
- [blocks_multiply_xx_0_3, '0', blocks_stream_to_vector_0_0_2, '0']
- [blocks_stream_to_vector_0, '0', krakensdr_doa_music_0, '0']
- [blocks_stream_to_vector_0_0, '0', krakensdr_doa_music_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', krakensdr_doa_music_0, '2']
- [blocks_stream_to_vector_0_0_0_0, '0', epy_block_0, '1']
- [blocks_stream_to_vector_0_0_1, '0', krakensdr_doa_music_0, '3']
- [blocks_stream_to_vector_0_0_2, '0', krakensdr_doa_music_0, '4']
- [blocks_vector_to_stream_0_2_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', fir_filter_xxx_0_0, '0']
- [channels_channel_model_0_0, '0', fir_filter_xxx_0_0_0, '0']
- [channels_channel_model_0_0_0, '0', fir_filter_xxx_0_0_1, '0']
- [channels_channel_model_0_0_0_0, '0', fir_filter_xxx_0_0_2, '0']
- [channels_channel_model_0_0_0_1, '0', fir_filter_xxx_0, '0']
- [cospas_sarsat_doa_0, '0', channels_channel_model_0, '0']
- [cospas_sarsat_doa_0, '1', channels_channel_model_0_0, '0']
- [cospas_sarsat_doa_0, '2', channels_channel_model_0_0_0, '0']
- [cospas_sarsat_doa_0, '3', channels_channel_model_0_0_0_1, '0']
- [cospas_sarsat_doa_0, '4', channels_channel_model_0_0_0_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0_2_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_xx_0, '1']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', squelcher_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_multiply_xx_0_0, '1']
- [fir_filter_xxx_0_0_0, '0', blocks_multiply_xx_0_1, '1']
- [fir_filter_xxx_0_0_1, '0', blocks_multiply_xx_0_2, '1']
- [fir_filter_xxx_0_0_2, '0', blocks_multiply_xx_0_3, '1']
- [krakensdr_doa_music_0, '0', epy_block_0, '0']
- [krakensdr_doa_music_0, '0', qtgui_vector_sink_f_0, '0']
- [krakensdr_krakensdr_source_0, '0', fir_filter_xxx_0, '0']
- [krakensdr_krakensdr_source_0, '1', fir_filter_xxx_0_0, '0']
- [krakensdr_krakensdr_source_0, '2', fir_filter_xxx_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '3', fir_filter_xxx_0_0_1, '0']
- [krakensdr_krakensdr_source_0, '4', fir_filter_xxx_0_0_2, '0']
- [squelcher_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0_1, '0']
- [virtual_source_0_0_1, '0', blocks_multiply_xx_0_2, '0']
- [virtual_source_0_0_2, '0', blocks_multiply_xx_0_3, '0']
- [virtual_source_0_1, '0', blocks_stream_to_vector_0_0_0_0, '0']

metadata:
  file_format: 1
