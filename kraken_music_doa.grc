options:
  parameters:
    generate_options: qt_gui
    id: kraken_music_doa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha_iir_0
  id: variable_qtgui_range
  parameters:
    comment: For Squelcher block
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: cpi_size
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '128'
  states: {}
- name: delay_time_s_0
  id: variable_qtgui_range
  parameters:
    comment: For Squelcher block
    start: '0'
    step: '0.5'
    stop: '5'
    value: '2'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '406.025'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: theta_deg
  id: variable_qtgui_range
  parameters:
    comment: Angle of incidence in degrees (0=North, 90=East)
    gui_hint: 0,0,1,4
    label: Angle of Incidence (degrees)
    start: '-180'
    step: '1'
    stop: '180'
    value: '45'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_2
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_3
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '360'
    type: float
  states: {}
- name: cospas_sarsat_doa_0
  id: cospas_sarsat_doa
  parameters:
    theta_deg: '45'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, mode='map_squelch', threshold=0.1):
              """
              mode: 'map_squelch' outputs zeros between bursts so the heatmap doesn't track false movement.
                    'compass_hold' persists the last burst indefinitely for visual UI dials.
              """
              gr.sync_block.__init__(
                  self,
                  name='Smart Vector Gate',
                  in_sig=[(np.float32, 360)],
                  out_sig=[(np.float32, 360)]
              )
              self.mode = mode 
              self.threshold = threshold
              self.held_vector = np.zeros(360, dtype=np.float32)

          def work(self, input_items, output_items):
              for i in range(len(input_items[0])):
                  current_vector = input_items[0][i]

                  # 1. Catch the MUSIC algorithm Divide-by-Zero (NaN) explosion
                  if np.isnan(current_vector).any():
                      is_valid = False
                  # 2. Check if the vector contains a strong, valid MUSIC peak
                  elif np.max(current_vector) > self.threshold:
                      is_valid = True
                      self.held_vector = np.copy(current_vector) # Save it to memory
                  else:
                      is_valid = False

                  # Output Logic
                  if self.mode == 'compass_hold':
                      # Continously push the last known heading (Dangerous if driving!)
                      output_items[0][i] = self.held_vector
                  else:
                      # 'map_squelch' - Push valid burst, otherwise output strict zeros
                      if is_valid:
                          output_items[0][i] = current_vector
                      else:
                          output_items[0][i] = np.zeros(360, dtype=np.float32)

              return len(output_items[0])
    mode: '''map_squelch'''
    threshold: '0.1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_2
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: krakensdr_doa_music_0
  id: krakensdr_doa_music
  parameters:
    array_dist: '0.22'
    array_type: '''UCA'''
    freq: freq
    num_elements: '5'
    vec_len: cpi_size//decimation
  states: {}
- name: krakensdr_krakensdr_source_0
  id: krakensdr_krakensdr_source
  parameters:
    ctrlPort: '5001'
    debug: 'False'
    freq: freq
    gain: '[40.2, 40.2, 40.2, 40.2, 40.2]'
    ipAddr: 127.0.0.1
    numChannels: '5'
    port: '5000'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate//decimation
    fc: '0'
    fftsize: '2048'
    name: CH_0 Decimated FFT
    type: complex
    update_time: '0.1'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: DOA Graph
    size: '360'
    srate: '1000'
    type: float
  states: {}
- name: squelcher_0
  id: squelcher
  parameters:
    alpha_iir: '0.01'
    decimation: decimation
    delay_time_s: '2'
    samp_rate: samp_rate
  states: {}
- name: squelcher_0_0
  id: squelcher
  parameters:
    alpha_iir: '0.01'
    decimation: decimation
    delay_time_s: '2'
    samp_rate: samp_rate
  states: {}
- name: squelcher_0_1
  id: squelcher
  parameters:
    alpha_iir: '0.01'
    decimation: decimation
    delay_time_s: '2'
    samp_rate: samp_rate
  states: {}
- name: squelcher_0_2
  id: squelcher
  parameters:
    alpha_iir: '0.01'
    decimation: decimation
    delay_time_s: '2'
    samp_rate: samp_rate
  states: {}
- name: squelcher_0_2_0
  id: squelcher
  parameters:
    alpha_iir: '0.01'
    decimation: decimation
    delay_time_s: '2'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', krakensdr_doa_music_0, '0']
- [blocks_stream_to_vector_0_0, '0', krakensdr_doa_music_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', krakensdr_doa_music_0, '2']
- [blocks_stream_to_vector_0_0_1, '0', krakensdr_doa_music_0, '3']
- [blocks_stream_to_vector_0_0_2, '0', krakensdr_doa_music_0, '4']
- [blocks_stream_to_vector_1, '0', krakensdr_doa_music_0, '0']
- [blocks_stream_to_vector_1_0, '0', krakensdr_doa_music_0, '4']
- [blocks_stream_to_vector_1_1, '0', krakensdr_doa_music_0, '3']
- [blocks_stream_to_vector_1_2, '0', krakensdr_doa_music_0, '1']
- [blocks_stream_to_vector_1_3, '0', krakensdr_doa_music_0, '2']
- [blocks_vector_to_stream_0_2_0, '0', qtgui_time_sink_x_0, '0']
- [cospas_sarsat_doa_0, '0', fir_filter_xxx_0_0, '0']
- [cospas_sarsat_doa_0, '1', fir_filter_xxx_0_0_0, '0']
- [cospas_sarsat_doa_0, '2', fir_filter_xxx_0_0_1, '0']
- [cospas_sarsat_doa_0, '3', fir_filter_xxx_0, '0']
- [cospas_sarsat_doa_0, '4', fir_filter_xxx_0_0_2, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0_2_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', squelcher_0, '0']
- [fir_filter_xxx_0_0, '0', squelcher_0_1, '0']
- [fir_filter_xxx_0_0_0, '0', squelcher_0_2_0, '0']
- [fir_filter_xxx_0_0_1, '0', squelcher_0_2, '0']
- [fir_filter_xxx_0_0_2, '0', squelcher_0_0, '0']
- [krakensdr_doa_music_0, '0', epy_block_0, '0']
- [krakensdr_krakensdr_source_0, '0', blocks_stream_to_vector_1, '0']
- [krakensdr_krakensdr_source_0, '0', fir_filter_xxx_0, '0']
- [krakensdr_krakensdr_source_0, '1', blocks_stream_to_vector_1_2, '0']
- [krakensdr_krakensdr_source_0, '1', fir_filter_xxx_0_0, '0']
- [krakensdr_krakensdr_source_0, '2', blocks_stream_to_vector_1_3, '0']
- [krakensdr_krakensdr_source_0, '2', fir_filter_xxx_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '3', blocks_stream_to_vector_1_1, '0']
- [krakensdr_krakensdr_source_0, '3', fir_filter_xxx_0_0_1, '0']
- [krakensdr_krakensdr_source_0, '4', blocks_stream_to_vector_1_0, '0']
- [krakensdr_krakensdr_source_0, '4', fir_filter_xxx_0_0_2, '0']
- [squelcher_0, '0', blocks_stream_to_vector_0, '0']
- [squelcher_0_0, '0', blocks_stream_to_vector_0_0_2, '0']
- [squelcher_0_1, '0', blocks_stream_to_vector_0_0, '0']
- [squelcher_0_2, '0', blocks_stream_to_vector_0_0_1, '0']
- [squelcher_0_2_0, '0', blocks_stream_to_vector_0_0_0, '0']

metadata:
  file_format: 1
