options:
  parameters:
    author: krakenrf
    generate_options: hb
    id: squelcher
    output_language: python
    title: Squelcher block
  states: {}

blocks:
- name: alpha_iir
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {state: disabled}
- name: decimation
  id: variable
  parameters:
    value: '128'
  states: {state: disabled}
- name: delay_time_s
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '5'
    value: '2'
  states: {state: disabled}
- name: alpha_iir
  id: parameter
  parameters:
    value: '0.01'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1e-6'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int((delay_time_s)*(samp_rate/decimation))
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: We now get the noise floor
    const: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '0.99'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: decimation
    type: eng_float
    value: '128'
  states: {}
- name: delay_time_s
  id: parameter
  parameters:
    value: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '1200000'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: alpha_iir
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_divide_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_threshold_ff_0, '0', blocks_float_to_complex_0, '0']
- [pad_source_1, '0', blocks_complex_to_mag_0, '0']
- [pad_source_1, '0', blocks_complex_to_mag_1, '0']
- [pad_source_1, '0', blocks_multiply_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
